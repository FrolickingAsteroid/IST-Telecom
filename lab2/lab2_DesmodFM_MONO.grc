options:
  parameters:
    generate_options: qt_gui
    id: DesFM_MONO
    output_language: python
    title: Desmodulação FM Mono
  states: {}

blocks:
- name: FM_station
  id: variable
  parameters:
    value: '94400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: BaseBandSpectrum
  id: qtgui_sink_x
  parameters:
    bw: '50000'
    fc: FM_station
    fftsize: '1024'
    name: '"RF monitor"'
    rate: '15'
    type: float
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: '500000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/Excelsis/Uni/3A_1S/Documents/MEEC/3o ano/Telecom/Lab/3º Lab - Aval/IQ_104,3MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', BaseBandSpectrum, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-237-gc49548c2
